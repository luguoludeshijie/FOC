# IAR project MotorCtrl_G474.ewp, settings and files
configuration MotorCtrl_G474 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474VE ST STM32G474VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\App; ..\Srv
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MotorCtrl_G474.hex
  ILINK.IlinkOutputFile: MotorCtrl_G474.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../App/: App.h
  group App/App_Com
    ../App/App_Com/: App_DBC.c App_DBC.h
  group App/App_Motor
    ../App/App_Motor/: Motor_Ctrl.c Motor_Ctrl.h Motor_Info.c Motor_Info.h
  group App/App_Task
    ../App/App_Task/: App_0P5ms_Task.c App_1000ms_Task.c App_100ms_Task.c App_10ms_Task.c App_1ms_Task.c App_20ms_Task.c App_5ms_Task.c App_Task.h
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: adc.c fdcan.c gpio.c main.c stm32g4xx_hal_msp.c stm32g4xx_it.c tim.c
    ../Core/Inc/: stm32g4xx_hal_conf.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_adc.c
  group Srv
    ../Srv/: Srv.h
  group Srv/Com/Com_CAN
    ../Srv/Com/Com_CAN/: SrvCan.c SrvCan.h
  group Srv/Com/Com_CAN/DBC
    ../Srv/Com/Com_CAN/DBC/: Com_DBC.c Com_DBC.h Com_DBC_Cfg.c Com_DBC_Cfg.h
  group Srv/Com/Com_CAN/UDS/Basie
    ../Srv/Com/Com_CAN/UDS/Base/: uds_port.c uds_port.h uds_service.c uds_service.h uds_tp.c uds_tp.h uds_tp_private.h
  group Srv/Com/Com_CAN/UDS/Service
    ../Srv/Com/Com_CAN/UDS/Service/: service_cfg.c service_cfg.h SID10_SessionControl.c SID10_SessionControl.h SID11_EcuReset.c SID11_EcuReset.h SID14_ClearDiagnosticInformation.c SID14_ClearDiagnosticInformation.h SID19_ReadDTCInformation.c SID19_ReadDTCInformation.h SID22_ReadDataByIdentifier.c SID22_ReadDataByIdentifier.h SID27_SecurityAccess.c SID27_SecurityAccess.h SID28_CommunicationControl.c SID28_CommunicationControl.h SID2E_WriteDataByIdentifier.c SID2E_WriteDataByIdentifier.h SID31_RoutineControl.c SID31_RoutineControl.h SID34_36_37_UpDownloadData.c SID34_36_37_UpDownloadData.h SID3E_TesterPresent.c SID3E_TesterPresent.h SID85_ControlDTCSetting.c SID85_ControlDTCSetting.h
  group Srv/Com/Com_CAN/XCP
    ../Srv/Com/Com_CAN/XCP/: xcp_cc_tc_ovram.c xcp_cfg.h xcp_def.h xcp_if.c xcp_par.c xcp_par.h XcpBasic.c XcpBasic.h
  group Srv/Com/Com_I2C/AS5600
    ../Srv/Com/Com_I2C/AS5600/: AS5600.c AS5600.h
  group Srv/Motor
    ../Srv/Motor/: Motor_Angle.c Motor_Angle.h Motor_Filter.c Motor_Filter.h Motor_Math.c Motor_Math.h Motor_Para.h Motor_Pid.c Motor_Pid.h Motor_Svpwm.c Motor_Svpwm.h Motor_transform.c Motor_transform.h
  group Srv/Sys
    ../Srv/Sys/: Sys_Task.c Sys_Task.h
