<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MotorCtrl_G474.ewp</path>
  </project>
  <batchBuild />
</workspace>
